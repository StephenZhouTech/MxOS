# Keil uVision project mxosDemo.uvprojx, settings and files
target MxOS_Pro (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: mxosDemo +hex
  AfterMake: fromelf --text -c -o "$L@L.s" "$L@L.axf"
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\..\cpu\cortex_m4;..\..\components\delay;..\..\components\sys;..\..\components\usart;..\..\libraries\stm32f407_fw_lib\include;.\include;..\..\components\log;..\..\bsp\include;..\..\components\lcd\st7735s;..\..\..\..\arch\arm\cortex_m4;..\..\..\..\kernel\include;..\..\..\..\kernel;..\..\..\..\platform;..\..\..\..\external\letter_shell
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../../cpu/cortex_m4/: startup_stm32f40_41xxx.s
  group Libraries
    ../../libraries/stm32f407_fw_lib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Components
    ../../components/log/: log.c
  group Bsp
    ../../bsp/src/: led.c
  group User
    ./src/: stm32f4xx_it.c system_stm32f4xx.c
  group MxOS
    ../../../../arch/arm/cortex_m4/: arch.c
    ../../../../kernel/source/: os_mem.c os_critical.c os_kernel.c os_scheduler.c os_task.c os_time.c os_printk.c os_sem.c os_mutex.c os_queue.c os_sw_timer.c os_shell.c
  group TestCase
    ./src/: tc_sem_main.c tc_suspend_main.c tc_mutex_main.c tc_queue_main.c tc_sw_timer_main.c tc_shell_main.c
  group Platform
    ../../../../platform/: platform.c
  group Shell
    ../../../../external/letter_shell/: shell.c shell_ext.c
